## configs/am335x_igep0033_RB30_defconfig
```kconfig
CONFIG_SPL=y
CONFIG_SYS_EXTRA_OPTIONS="SDRAM_H5TQ4G63AFR"
+S:CONFIG_ARM=y
+S:CONFIG_TARGET_AM335X_IGEP0033=y
```
